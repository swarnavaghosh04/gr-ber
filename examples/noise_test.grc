options:
  parameters:
    author: Swarnava Ghosh
    copyright: Swarnava Ghosh
    generate_options: qt_gui
    id: noise_test
    output_language: python
    title: Noise Test
  states: {}

blocks:
- name: msg
  id: variable
  parameters:
    value: '"0001000101001010011101010011001010111100101111011101"'
  states: {}
- name: msg_arr
  id: variable
  parameters:
    value: '[ int(x) for x in list(msg) ]'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    label: Noise Voltage
    start: '0'
    step: '0.01'
    stop: '2'
    value: '0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ber_async_ber_calculator_0
  id: ber_async_ber_calculator
  parameters:
    sequence: msg
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: len(msg)*20
    max_iter: '4000'
    scale: 1/len(msg)/20
    type: float
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: msg_arr
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: noise_voltage
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_gmsk_demod_0
  id: digital_gmsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '8'
  states: {}
- name: digital_gmsk_mod_0
  id: digital_gmsk_mod
  parameters:
    bt: '0.35'
    do_unpack: 'False'
    samples_per_symbol: '8'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    marker1: '0'
    size: '1024'
    srate: samp_rate
    type: float
    ymax: '1.25'
    ymin: '-0.25'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [ber_async_ber_calculator_0, '0', blocks_moving_average_xx_0, '0']
- [ber_async_ber_calculator_0, '1', blocks_null_sink_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_moving_average_xx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']
- [blocks_vector_source_x_0, '0', digital_gmsk_mod_0, '0']
- [channels_channel_model_0, '0', digital_gmsk_demod_0, '0']
- [channels_channel_model_0, '0', qtgui_time_sink_x_2, '0']
- [digital_gmsk_demod_0, '0', ber_async_ber_calculator_0, '0']
- [digital_gmsk_mod_0, '0', channels_channel_model_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
