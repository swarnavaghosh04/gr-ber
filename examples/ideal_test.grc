options:
  parameters:
    author: Swarnava Ghosh
    copyright: Swarnava Ghosh
    generate_options: qt_gui
    id: ideal_test
    output_language: python
    title: Ideal Test
  states: {}

blocks:
- name: msg
  id: variable
  parameters:
    value: '"0001000101011100101001111010011110101011010110001111010101001111011101110110101"'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: ber_async_ber_calculator_0
  id: ber_async_ber_calculator
  parameters:
    sequence: '0001000101011100101001111010011110101011010110001111010101001111011101110110101'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[ int(i) for i in msg ]'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [ber_async_ber_calculator_0, '0', qtgui_time_sink_x_0, '0']
- [ber_async_ber_calculator_0, '1', blocks_null_sink_0, '0']
- [blocks_vector_source_x_0, '0', ber_async_ber_calculator_0, '0']
- [blocks_vector_source_x_0, '0', blocks_throttle2_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
